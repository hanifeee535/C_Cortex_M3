# Keil uVision project 1602_lcd.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 1602_lcd
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: EXTI_lib.c gpio_lib.c header.h i2c_lib.c main.c oled_i2c_lib.c spi_lib.c systic_lib.c timer_lib.c USART_Lib.c 1602_lcd_lib.c oled_header.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
